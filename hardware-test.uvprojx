# Keil uVision project hardware-test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RD STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: YJCS_SV_02_00_00 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: _FLASH_PROG,RF_Test,HV=0x48563134,VERSION=0x56323030,SYS=1
  c include: .\SysTem;.\Library\uCOS-II;.\Library\inc;.\BSP;.\APP\LTE;.\APP\Local_Protocl;.\APP\RF;.\APP\RTC;.\APP\NW_Protocol;.\BSP;.\APP\Delay;.\APP\Meteorology;.\APP\FATFS
  memory RVCT4: ROM 0x8027000 size 0x21000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Systerm
    ./SysTem/: main.c SysConfigVC.c stm32f10x_it.c MemConfig.h stm32f10x_conf.h stm32f10x_it.h cortexm3_macro.s
  group Ucos
    ./SysTem/: stm32f10x_vector.s
    ./Library/uCOS-II/: ucos_ii.c os_cpu_a.s
  group Lib
    ./Library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ./BSP/: Bsp_adc.c Bsp_AM2302.c Bsp_fm.c bsp_RTC.c bsp_spi.c Bsp_UART.c Bsp_W25Q256.c bsp_WDG.c CRC.C Bsp_NFlash.c Bsp_Ds18b20.c NRTC.c NumToAscii.c
  group FatFs
    ./APP/FATFS/: diskio.c ff.c ffsystem.c ffunicode.c
  group Local_Protocol
    ./APP/Local_Protocl/: Local_Protocl.c
  group LTE
    ./APP/LTE/: LTE.c ME909S.c
  group NW_Protocol
    ./APP/NW_Protocol/: NW_Protocol.c Extend_Protocol.c
  group RF
    ./APP/RF/: RF.c
  group Delay
    ./APP/Delay/: delay.c
  group ReadMe
    ./: 修订说明.txt
